# Keil uVision project wifi+led.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: wifi+led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c stc8.h uart1.c uart1.h uart2.c uart2.h led_task.h led_task.c Char.h Ref_Sys.c Ref_Sys.h wifi.c wifi.h
